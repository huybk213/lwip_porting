# Keil uVision project lwip_porting.uvprojx, settings and files
target lwip_porting (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: lwip_porting +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F429xx,MC60
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\platform_stm32\app_debug;..\..\..\gsm;..\..\..\app_http;..\..\..\mqtt_client;..\..\..\platform_stm32\SEGGER_RTT_V698b\RTT;..\..\..\platform_stm32\arch;..\..\..\lwip-2.1.2\src\api;..\..\..\lwip-2.1.2\src\apps\http;..\..\..\lwip-2.1.2\src\apps\mdns;..\..\..\lwip-2.1.2\src\apps\sntp;..\..\..\lwip-2.1.2\src\apps\mqtt;..\..\..\lwip-2.1.2\src\include;..\..\..\lwip-2.1.2\src\include\lwip;..\..\..\lwip-2.1.2\src\include\lwip\apps;..\..\..\lwip-2.1.2\src\include\lwip\priv;..\..\..\lwip-2.1.2\src\include\lwip\prot;..\..\..\lwip-2.1.2\src\include\netif;..\..\..\lwip-2.1.2\src\include\netif\ppp;..\..\..\lwip-2.1.2\src\include\netif\ppp\polarssl;..\..\..\platform_stm32
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lwip/app
    ../../../lwip-2.1.2/src/apps/http/: http_client.c
    ../../../lwip-2.1.2/src/apps/mdns/: mdns.c
    ../../../lwip-2.1.2/src/apps/mqtt/: mqtt.c
    ../../../lwip-2.1.2/src/apps/sntp/: sntp.c
  group lwip/core
    ../../../lwip-2.1.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/netif
    ../../../lwip-2.1.2/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
  group lwip/porting
    ../../../platform_stm32/: lwipopts.h sys_timer.c
    ../../../platform_stm32/arch/: cc.h cpu.h
  group lwip/ipv4
    ../../../lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group app_debug
    ../../../platform_stm32/app_debug/: app_debug.c app_debug.h
  group Segger_RTT
    ../../../platform_stm32/SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group gsm
    ../../../gsm/: gsm.h gsm_data_layer.c gsm_hardware_layer.c gsm_utilities.c gsm_utilities.h
  group mqtt_client
    ../../../mqtt_client/: mqtt_client.c mqtt_client.h
  group app_http
    ../../../app_http/: app_http.c app_http.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usart.c stm32f4xx_ll_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c
software components: CMSIS:CORE 4.3.0
